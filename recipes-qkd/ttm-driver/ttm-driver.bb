DESCRIPTION = "ttdriver" 
SECTION = "examples" 
LICENSE = "CLOSED" 
PR = "r0" 
inherit module
S = "${WORKDIR}/ttdriver"
SRC_URI = "file:///home/lukas/yocto/openembedded-core/ttdriver.zip"


